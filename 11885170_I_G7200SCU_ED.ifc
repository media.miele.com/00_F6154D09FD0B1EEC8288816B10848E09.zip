Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-08-24T10:59:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 24 10:59:50 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{EB83C54C-690C-41C1-BEE6-BC511FA33EF3}\ifc * Database version: 5507 * Database creation date: Tue Aug 24 10:59:49 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 24 10:59:49 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 24 10:59:49 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21720037_I_11885170_G7200SCU_ED, 11885170_I_G7200SCU_ED:21720037_I_11885170_G7200SCU_ED:209578
In: Level 1
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 21720037_I_11885170_G7200SCU_ED
Pset_ManufacturerTypeInformation - Manufacturer: Miele
